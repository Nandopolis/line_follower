# Keil uVision project line_follower.uvprojx, settings and files
target Target 1 (5060020::V5.06 (build 20)::ARMCC)
  device: STM32F030F4 STMicroelectronics
  pack: Keil.STM32F0xx_DFP.1.5.0
  cpu: IROM(0x08000000,0x4000) IRAM(0x20000000,0x1000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: line_follower +hex
  c flags: Optim=3 OneElfS=1 wLevel=2
  c define: STM32F030
  memory RVCT4: ROM 0x8000000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x1000
  link misc: --info stack
  group Source
    ./: main.c snippets.c LowPass.c
software components: CMSIS:CORE 5.0.2, CMSIS:DSP 1.5.2, CMSIS:RTOS:Keil RTX 4.81.1, Device:Startup 2.2.3
